# Keil uVision project STM32H743IIT6.uvprojx, settings and files
target STM32H743IIT6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H743IIT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_PWR_LDO_SUPPLY,HAL_TIM_MODULE_ENABLED
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/AI/Inc;../X-CUBE-AI/App;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;..\Core\Src\video;..\Core\Inc\video;..\Drivers\STM32H7xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: led.c lcd_fonts.c lcd_image.c touch_iic.c touch_800x480.c sccb.c main.c gpio.c dcmi.c dma.c dma2d.c fmc.c ltdc.c sdmmc.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c jpeg_encode.c gallery.c jpeg_utils.c photo_capture.c delay.c dht11.c DS.c lunar.c sai.c sensors.c tlv320aic3254.c wav_player.c i2c.c cloud_upload.c image_utils.c display_utils.c ui_panels.c buzzer.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_ll_adc.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group video
    ../Core/Src/video/: mode_switch.c video_avi.c video_rec.c video_ui.c
software components: CMSIS:CORE 4.3.0
